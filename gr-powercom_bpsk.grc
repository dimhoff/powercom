<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>powercom_demod_bpsk</value></param>
<param><key>author</key><value>D. Imhoff</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Powercom BPSK Demodulator</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>float(carrier_freq) / bit_periods</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bit_periods</value></param>
<param><key>value</key><value>param_bit_periods</value></param>
<param><key>gui_hint</key><value>qttab0@2</value></param>
<param><key>label</key><value>Periods per bit</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>2000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>carrier_freq</value></param>
<param><key>value</key><value>param_carrier_freq</value></param>
<param><key>gui_hint</key><value>qttab0@2</value></param>
<param><key>label</key><value>Carrier Freq. (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>4000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>input_gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>gui_hint</key><value>qttab0@2</value></param>
<param><key>label</key><value>Input Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.01</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_loop_bw_div</value></param>
<param><key>value</key><value>loop_bw_divider</value></param>
<param><key>gui_hint</key><value>qttab0@2</value></param>
<param><key>label</key><value>Costas Loop Bandwidth Divider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_raw_signal_displ_attenuation</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>qttab0@2</value></param>
<param><key>label</key><value>Raw signal level (%)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_threshold</value></param>
<param><key>value</key><value>param_threshold</value></param>
<param><key>gui_hint</key><value>qttab0@0</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>xlating_taps</value></param>
<param><key>cutoff_freq</key><value>carrier_freq / bit_periods /2</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>var_threshold</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1</value></param>
<param><key>const</key><value>-var_threshold</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>server</key><value>False</value></param>
<param><key>port</key><value>5555</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_tcp_source</key>
<param><key>id</key><value>blks2_tcp_source_0</value></param>
<param><key>addr</key><value>param_sample_server</value></param>
<param><key>server</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>port</key><value>12345</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>comment</key><value>Try to sync with the delay 
introduced by the various 
filters in the decoding stage.</value></param>
<param><key>delay</key><value>9300</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>input_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>comment</key><value>GUI Gain control</value></param>
<param><key>const</key><value>var_raw_signal_displ_attenuation/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>var_threshold</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>-var_threshold</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/powercom_bpsk_demodulated.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>2 * 3.14 / var_loop_bw_div</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1</value></param>
<param><key>center_freq</key><value>power_freq + carrier_freq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>xlating_taps</value></param>
<param><key>type</key><value>fcc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>loop_bw_divider</value></param>
<param><key>label</key><value>Costas loop bandwidth divider</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_bit_periods</value></param>
<param><key>label</key><value>periods per bit</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_carrier_freq</value></param>
<param><key>label</key><value>Carrier Frequency (Hz)</value></param>
<param><key>short_id</key><value>c</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>36</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_sample_server</value></param>
<param><key>label</key><value>Sample server</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>raspberrypi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_threshold</value></param>
<param><key>label</key><value>threshold</value></param>
<param><key>short_id</key><value>t</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.250</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>comment</key><value>Resample to fixed bit rate. This way 
gr-powercom_decode doesn't have to know 
about the carrier freq and periods per bit settings.</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>baud_rate * 100.0 / samp_rate</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>power_freq</value></param>
<param><key>label</key><value>Frequency of power network</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>qttab0@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>Raw Input</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>20</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>qttab0@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>0.25</value></param>
<param><key>color1</key><value>"dark red"</value></param>
<param><key>label1</key><value>Raw Rectified Input Signal</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>analog stream</value></param>
<param><key>alpha3</key><value>1</value></param>
<param><key>color3</key><value>"cyan"</value></param>
<param><key>label3</key><value>Threshold (upper)</value></param>
<param><key>style3</key><value>3</value></param>
<param><key>alpha4</key><value>1</value></param>
<param><key>color4</key><value>"green"</value></param>
<param><key>label4</key><value>Threshold (lower)</value></param>
<param><key>style4</key><value>3</value></param>
<param><key>color5</key><value>"blue"</value></param>
<param><key>label5</key><value>Digital stream</value></param>
<param><key>nconnections</key><value>5</value></param>
<param><key>size</key><value>8192</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_delay</key><value>0.1</value></param>
<param><key>tr_level</key><value>0.75</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qttab0</value></param>
<param><key>label0</key><value>Scope</value></param>
<param><key>label1</key><value>Spectrum</value></param>
<param><key>label2</key><value>Settings</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate in Hz</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blks2_tcp_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blks2_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_float_to_uchar_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
